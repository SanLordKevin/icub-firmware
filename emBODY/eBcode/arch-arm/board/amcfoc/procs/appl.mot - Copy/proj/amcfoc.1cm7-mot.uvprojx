# Keil uVision project amcfoc.1cm7-mot.uvprojx, settings and files
target amcfoc.1cm7-mot (6230000::V6.23::ARMCLANG)
  device: STM32H745IIKx:CM7 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x38000000,0x00010000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) XRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: amcfoc_mot +hex
  AfterMake: cmd.exe /C copy .\obj\amcfoc_mot.hex ..\bin\amcfoc.1cm7.app.mot.test.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=8 wLevel=3
  c define: USE_ICC_COMM USE_ICC_CAN_COMM USE_STM32HAL STM32HAL_BOARD_AMCFOC_1CM7 STM32HAL_DRIVER_V1A0
  c misc: -D_dont_temporaryDISABLEqencMBD -D_dont_DEBUG_canQENCemission -D_dont_MBD_foc_keep_degenerated_code -DSTM32HAL_dualcore_BOOT_cm4master -Wno-pragma-pack -Wno-deprecated-register -DEMBOT_USE_rtos_osal
  c include: ..\..\..\..\..\libs\lowlevel\stm32hal\api;..\..\..\..\..\libs\highlevel\abslayer\osal\api;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\core;..\..\..\..\..\..\..\..\..\icub-firmware-shared\embot\tools;..\..\..\..\..\..\..\..\..\icub-firmware-shared\can\canProtocolLib;..\..\..\..\..\embot\hw;..\..\..\..\..\embot\os;..\..\..\..\..\embot\app;..\..\..\..\..\libs\midware\eventviewer\api;..\..\..\..\..\embot\app\bldc;..\..\..\..\..\embot\prot\can;..\..\..\..\..\embot\app\eth;..\src\app-board-amc1cm7;..\..\..\..\..\libs\highlevel\services\embenv\api;..\..\..\bsp\shared;..\..\..\bsp\portable;..\..\..\bsp\cm7;..\..\..\bsp\portable\motor;..\src\bldc-mbd-moc;..\..\..\..\..\mbd\amcfoc\control-foc;..\..\..\..\..\mbd\amcfoc\control-outer;..\..\..\..\..\mbd\amcfoc\estimation-velocity;..\..\..\..\..\mbd\amcfoc\filter-current;..\..\..\..\..\mbd\amcfoc\motion-controller;..\..\..\..\..\mbd\amcfoc\supervisor;..\..\..\..\..\mbd\amcfoc\supervisor-tx;..\..\..\..\..\mbd\amcfoc\sharedutils;..\..\..\..\..\mbd\amcfoc\iterative-motion-controller\;..\..\..\..\..\mbd\amcfoc\process-sensors;..\..\..\..\..\mbd\amcfoc\trajectory-planner
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x38000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\cfg\amcfoc.1cm7-application-mot.sct
  link misc: --diag_suppress=L6329
  group main
    ../src/: amcfoc1cm7-main2.cpp
  group embot::app::board::amcfoc-1cm7
    ../src/app-board-amc1cm7/: embot_app_board_amcfoc_1cm7_info.cpp embot_app_board_amcfoc_1cm7_theCANagentCORE.cpp embot_app_board_amcfoc_1cm7_theMBD.cpp
    ../../../../../embot/app/bldc/: embot_app_bldc_MBD_interface.cpp embot_app_bldc_theMC2agent.cpp
    ../src/bldc-mbd-moc/: embot_app_bldc_MBD_interface_mock.cpp
  group embot::app::bldc::theApplication::CtrlCfg
    ../src/app-board-amc1cm7/: embot_app_board_amcfoc_1cm7_test.cpp embot_app_board_amcfoc_1cm7_mbd.icc.cpp embot_app_board_amcfoc_1cm7_mbd.demo.cpp
  group stm32hal
    ../cfg/: stm32hal.h7.startup.amcfoc.CM7.s
    ../../../../../libs/lowlevel/stm32hal/lib/: stm32hal.h7.amcfoc.1cm7.v1A0.lib stm32hal.h7.amcfoc.1cm7.v1B5.lib
    ../../../../../libs/lowlevel/stm32hal/src/driver/stm32h7-v1A0/extra/: system_stm32h7xx-cm4-cm7-gated.c
  group rtos
    ../../../../../libs/highlevel/abslayer/osal/lib/: osal.cm4.dbg.lib
    ../../../../../libs/midware/eventviewer/src/: eventviewer.c
  group embot::core
    ../../../../../../../../../icub-firmware-shared/embot/core/: embot_core.cpp embot_core_binary.cpp embot_core_utils.cpp
  group embot::hw
    ../../../../../embot/hw/: embot_hw_bsp.cpp embot_hw.cpp embot_hw_gpio.cpp embot_hw_led.cpp embot_hw_sys.cpp embot_hw_flash.cpp embot_hw_dualcore.cpp embot_hw_can.cpp embot_hw_icc_ltr.cpp embot_hw_icc_mem.cpp embot_hw_icc_sig.cpp embot_hw_mtx.cpp embot_hw_button.cpp embot_hw_motor.cpp embot_hw_timer.cpp embot_hw_testpoint.cpp embot_hw_icc_printer.cpp embot_hw_motor_bldc.cpp
  group embot::os
    ../../../../../embot/os/: embot_os.cpp embot_os_Action.cpp embot_os_theCallbackManager.cpp embot_os_theScheduler.cpp embot_os_theTimerManager.cpp embot_os_Thread.cpp embot_os_Timer.cpp embot_os_rtos.cpp
  group embot::app
    ../../../../../embot/app/eth/: embot_app_eth_theICCservice.cpp embot_app_eth_theICCserviceROP.cpp embot_app_eth_theICCserviceCAN.cpp
    ../../../../../embot/app/: embot_app_theLEDmanager.cpp embot_app_scope.cpp
    ../../../../../../../../../icub-firmware-shared/embot/tools/: embot_tools.cpp
  group embot::hw::lowlevel
    ../../../../../embot/hw/: embot_hw_lowlevel.cpp
  group embot::app::bldc
    ../../../../../embot/app/bldc/: embot_app_bldc_theCOMMcanicc.cpp embot_app_bldc_theApplication.cpp embot_app_bldc_theCTRL.cpp embot_app_bldc_theMSGbroker.cpp
  group embot::prot::can
    ../../../../../embot/prot/can/: embot_prot_can.cpp embot_prot_can_analog_periodic.cpp embot_prot_can_analog_polling.cpp embot_prot_can_bootloader.cpp embot_prot_can_inertial_periodic.cpp embot_prot_can_motor_periodic.cpp embot_prot_can_motor_polling.cpp embot_prot_can_skin_periodic.cpp
  group embot::app-others
    ../../../../../embot/app/: embot_app_application_theCANparserCORE.cpp embot_app_application_theCANtracer.cpp embot_app_application_theCANparserMC2.cpp
  group embot::hw::bsp-core-cm7
    ../../../bsp/cm7/: embot_hw_bsp_amcfoc_1cm7.cpp
  group embot::hw::bsp-core-shared
    ../../../bsp/shared/: embot_hw_dualcore_bsp_amcfoc.cpp embot_hw_can_bsp_amcfoc.cpp embot_hw_flash_bsp_amcfoc.cpp embot_hw_gpio_bsp_amcfoc.cpp embot_hw_led_bsp_amcfoc.cpp embot_hw_led_bsp_pinout_amcfoc.h embot_hw_bsp_DRIVER_amcfoc.cpp
  group embot::hw::bsp-icc-shared
    ../../../bsp/shared/: embot_hw_icc_bsp_amcfoc.cpp embot_hw_mtx_bsp_amcfoc.cpp
  group embot::hw::bsp-motor
    ../../../bsp/portable/: embot_hw_motor_bldc_bsp_amcfoc.cpp
    ../../../bsp/portable/motor/: embot_hw_motor_hall.cpp embot_hw_motor_adc.cpp embot_hw_motor_enc.cpp embot_hw_motor_pwm.cpp embot_hw_analog.cpp
  group mbd::sharedutils
    ../../../../../mbd/amcfoc/sharedutils/: const_params.cpp mul_s32_sat.cpp mul_wide_s32.cpp rt_hypotf.cpp rt_roundf.cpp rt_remf.cpp
  group mbd
    ../../../../../mbd/amcfoc/sharedutils/: rtw_enable_disable_motors.c rtw_motor_config.c
    ../../../../../mbd/amcfoc/iterative-motion-controller/: iterative_motion_controller.cpp
  group mbd::supervisor
    ../../../../../mbd/amcfoc/supervisor/: supervisor.cpp
  group mbd::supervisor-tx
    ../../../../../mbd/amcfoc/supervisor-tx/: SupervisorFSM_TX.cpp
  group mbd::control-outer
    ../../../../../mbd/amcfoc/control-outer/: position_velocity_cascade.cpp
  group mbd::control-foc
    ../../../../../mbd/amcfoc/control-foc/: control_foc.cpp FOCInnerLoop.cpp
  group mbd::estimator-velocity
    ../../../../../mbd/amcfoc/estimation-velocity/: estimation_velocity.cpp
  group mbd::filter-current
    ../../../../../mbd/amcfoc/filter-current/: filter_current.cpp
  group mbd::motion-controller
    ../../../../../mbd/amcfoc/motion-controller/: motion_controller.cpp motion_controller_data.cpp
  group mbd::process-sensors
    ../../../../../mbd/amcfoc/process-sensors/: process_sensors.cpp
  group mbd::trajectory-planner
    ../../../../../mbd/amcfoc/trajectory-planner/: trajectory_planner.cpp
